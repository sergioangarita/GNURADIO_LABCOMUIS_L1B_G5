options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: TransAM
    output_language: python
    title: TransAM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: USSB = 1 LSSB = -1
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5E6/32
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: calculopotenciacomunicaciones_0
  id: calculopotenciacomunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: envolventecomplejaSSB_0
  id: envolventecomplejaSSB
  parameters:
    Ac: Ac
    k: K
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', calculopotenciacomunicaciones_0, '0']
- [analog_sig_source_x_0, '0', envolventecomplejaSSB_0, '0']
- [envolventecomplejaSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [envolventecomplejaSSB_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
